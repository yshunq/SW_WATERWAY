# Keil uVision project stc8f2k08s2 sop16 demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 1 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\user;..\display;..\common;..\cut;..\count
  group USER
    ../user/: MAIN.C pwm.c timer.c UART.C 24cxx.c adc.c
  group MAIN
    ../main/: main_interface.c XS_waiting.c XS_advanced_settings.c XS_sw_work.c XS_guide.c XS_loading.c XS_setting_power.c XS_probe_mode.c XS_basic_settings.c
  group COMMON
    ../common/: init.c ads7843.c display.c eeprom_data.c other.c key.c
  group display
    ../display/: dis_sw_work.c
  group cut
    ../cut/: cut_sw_work.c
  group count
    ../count/: count_sw_work.c
